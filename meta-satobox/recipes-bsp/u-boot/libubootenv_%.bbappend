
# Update to latest 0.3.7 release, which includes support for environment variable flags
SRCREV = "1e3511ed77f794ee5decc0974d54c8e5af26f64c"
PV = "0.3.7"
