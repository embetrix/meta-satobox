do_compile[nostamp] = "1"
