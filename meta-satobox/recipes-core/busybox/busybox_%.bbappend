FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SYSTEMD_PACKAGES=""

SRC_URI += "file://busybox.cfg"

