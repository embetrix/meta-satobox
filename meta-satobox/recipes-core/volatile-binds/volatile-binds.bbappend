VOLATILE_BINDS += "\
                /var/data/etc/certs /etc/certs\n\
                /var/data/home/root /home/root\n\
                /var/data/specter /var/specter\n\
                /var/data/var/tor /var/tor\n"
